options:
  parameters:
    author: genesys
    generate_options: qt_gui
    id: ris_tx
    output_language: python
    title: ris_tx
  states: {}

blocks:
- name: freq_0
  id: variable
  parameters:
    value: 890e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/genesys/Desktop/txData.bin
    offset: '10'
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: IQ
    name: Tx Signal
    size: '200000'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(freq_0,1e6)
    clock_rate: 200e6
    clock_source0: external
    dev_args: '"addr=192.168.50.2"'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: '"A:0"'
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0_1_1_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
